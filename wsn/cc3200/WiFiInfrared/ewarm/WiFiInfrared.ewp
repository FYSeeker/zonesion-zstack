# IAR project WiFiInfrared.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ewarm; USER_INPUT_ENABLE
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../; ../../common/; ../../../example/common/; ../../../driverlib/; ../../../inc/; ../../../simplelink/; ../../../simplelink/source; ../../../simplelink/include; ../../common/dev; ../src; ../../..
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WiFiInfrared.bin
  ILINK.IlinkOutputFile: WiFiInfrared.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkAdditionalLibs: ../../../simplelink/ewarm/NON_OS/Exe/simplelink.a; ../../../driverlib/ewarm/Release/Exe/driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: readme.txt
  group common
    ../../common/: at-uart.c at.c main.c zxbee-inf.c zxbee-sys-command.c zxbee.c
    ../../../example/common/: startup_ewarm.c
  group dev
    ../../../driverlib/: adc.c gpio.c pin.c
    ../../common/dev/: led.c pinmux.c relay.c systick_if.c ucfg.c
    ../../../example/common/: uart_if.c udma_if.c
  group sensor
    ../src/: infrared.c sensor.c sensor.h UserAt.c
